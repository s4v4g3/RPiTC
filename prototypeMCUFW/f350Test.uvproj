# Keil uVision project f350Test.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F350 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x1FFF) CLOCK(50000000)
  output: f350Test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./src/: main.c
